options:
  parameters:
    author: anes
    generate_options: qt_gui
    id: untitled1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 433.2e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 256e3
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '16'
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: 256e3
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.01'
    threshold: '-40'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '16000'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', analog_simple_squelch_cc_0, '0']
- [analog_am_demod_cf_0, '0', audio_sink_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_am_demod_cf_0, '0']
- [soapy_rtlsdr_source_0, '0', analog_agc_xx_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
